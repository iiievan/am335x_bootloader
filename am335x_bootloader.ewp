# IAR project am335x_bootloader.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: AM3358 TexasInstruments AM3358
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 53
  General.FPU2: 3
  ICCARM.CCDefines: am335x
  ICCARM.CCIncludePath2: app; app\include; startup; utils; regs; periph; \periph\pins; drivers
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 1
  AARM.AUserIncludes: app; startup; utils; regs; periph; \periph\pins
  OBJCOPY.OOCOutputFile: am335x_bootloader.bin
  postbuild: "gen_mlo\gen_mlo.exe"  "$TARGET_BPATH$.bin" "$TARGET_DIR$\MLO"
  ILINK.IlinkOutputFile: am335x_bootloader.out
  ILINK.IlinkIcfFile: am335x_bootloader.icf
  ILINK.IlinkProgramEntryLabel: Entry
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ICCARM.IccLang: 0
  group (top)
    ./: am335x_bootloader.icf
  group app
    app/: board.hpp init.cpp init.h main.cpp
  group drivers
    drivers/: serial.cpp serial.hpp
  group periph
    periph/: am335x_dmtimer.cpp am335x_dmtimer.h am335x_gpio.cpp am335x_gpio.h am335x_intc.cpp am335x_intc.h am335x_uart.cpp am335x_uart.hpp sys_timer.h
  group periph/pins
    periph/pins/: am3358zcz_pins.cpp am3358zcz_pins.hpp pin.cpp pin.h
  group regs
    regs/: CONTROL_MODULE.CPP CONTROL_MODULE.h DMTIMER.h DMTIMER1MS.h EMIF.hpp GPIO.h INTC.h MMCHS.hpp PRCM.cpp PRCM.h UART.hpp WDT.hpp
  group startup
    startup/: cp15.S cpu.S exceptionhandler.S init.S
  group utils
    utils/: paired_buffer.h ring_buffer.hpp sw_Timer.cpp sw_Timer.h utils.c utils.h
